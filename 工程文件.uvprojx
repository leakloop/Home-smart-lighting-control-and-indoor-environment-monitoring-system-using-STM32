# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\HARDWARE\scr
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: delay.c timer4.c stm32f10x_it.c usart2.c led.c wifi.c mqtt.c timer3.c usart1.c timer1.c key.c 24c02.c iic.c timer2.c dht11.c sys.c OLED.c PIR.c BH1750.c RGB.c MQ135.c stm32f10x_adc.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
